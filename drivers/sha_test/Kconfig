## drivers/sha_test/Kconfig
```kconfig
menu "test for sha216/512"

comment "Test sha_test"
config SHA_TEST

tristate "Sha_test"

endmenu
```
